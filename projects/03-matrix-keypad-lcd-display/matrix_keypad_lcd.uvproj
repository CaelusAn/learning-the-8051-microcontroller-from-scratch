# Keil uVision project matrix_keypad_lcd.uvproj, settings and files
target Matrix Keypad LCD Display (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: matrix_keypad_lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd1602.c lcd1602.h public.c public.h matrix_key.c matrix_key.h
