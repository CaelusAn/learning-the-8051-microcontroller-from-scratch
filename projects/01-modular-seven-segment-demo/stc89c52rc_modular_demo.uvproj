# Keil uVision project stc89c52rc_modular_demo.uvproj, settings and files
target STC89C52RC Modular Demo (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: stc89c52rc_modular_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c public.h public.c seven_segment.c seven_segment.h
