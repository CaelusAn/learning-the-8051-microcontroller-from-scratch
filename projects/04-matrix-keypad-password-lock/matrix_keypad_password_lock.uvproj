# Keil uVision project matrix_keypad_password_lock.uvproj, settings and files
target Matrix Keypad Password Lock (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: matrix_keypad_password_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd1602.c lcd1602.h public.c public.h matrix_key.c matrix_key.h password_lock.c password_lock.h timer.c timer.h
